# Keil uVision project USBD_HID.uvprojx, settings and files
target APM32F072 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USBD_HID
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USB_DEVICE,BOARD_APM32F072_EVAL,APM32F072xB
  c include: ..\..\..\..\..\..\Boards;..\..\..\..\..\..\Boards\Board_APM32F072_MINI\inc;..\..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Class\HID\Inc;..\..\..\..\..\..\Middlewares\APM32_USB_Library\Device\Core\Inc;..\..\Include;..\..\..\..\..\..\Libraries\TSC_Device_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App/Bsp
    ../../../../../../Boards/: board.c
    ../../Source/: tsc_user.c board_apm32f072_eval.c bsp_lcd.c
    ../../../../../../Boards/Board_APM32F072_MINI/src/: bsp_delay.c
  group App/User
    ../../Source/: main.c apm32f0xx_int.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ./: startup_apm32f072.s
    ../../Source/: system_apm32f0xx.c
  group Libraries/APM32F0xx_Std_Driver
    ../../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c apm32f0xx_usb.c apm32f0xx_usb_device.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/APM32_USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../Middlewares/APM32_USB_Library/Device/Class/HID/Src/: usbd_hid.c
  group TouchDriver
    ../../../../../../Libraries/TSC_Device_Lib/src/: tsc.c tsc_acq.c tsc_dxs.c tsc_ecs.c tsc_filter.c tsc_linrot.c tsc_object.c tsc_time.c tsc_touchkey.c
